# Keil uVision project parkbox.uvprojx, settings and files
target stm32f1xx_bl (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pb_bl +hex
  AfterMake: fromelf.exe --bin -o f103_bl/pb_bl.bin f103_bl/pb_bl.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,BOARD_STM32F1XX,PB_BOOTLOADER
  c include: ..\..\common;..\..\hardware\board\stm32f1xx\startup;..\..\hardware\board\stm32f1xx\STM32F10x_StdPeriph_Driver\inc;..\..\hardware\board\stm32f1xx;..\..\hardware\hal;..\..\thirdparty\FreeRTOS\Source\include;..\..\thirdparty\FreeRTOS\Source\portable\stm32f1xx;..\..\middleware;..\..\modules\pb_bootloader;..\..\modules\pb_firmware_manage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group pb_firmware_manage
    ../../modules/pb_firmware_manage/: pb_firmware_manage.c
  group pb_bl
    ../../modules/pb_bootloader/: pb_bl_main.c pb_bl_upgrade.c ymodem.c pb_bl_dbg.c
  group pb_app
    ../../modules/pb_application/: pb_app_main.c
  group pb_io
    ../../modules/pb_application/pb_io/: pb_io_monitor_main.c pb_io_main.c pb_io_alarm.c pb_io_drv.c pb_io_indicator_led.c pb_io_aircon.c
  group pb_util
    ../../modules/pb_application/pb_util/: pb_util.c pb_function_polling.c
  group pb_fota
    ../../modules/pb_application/pb_fota/: pb_fota.c
  group pb_crypto
    ../../modules/pb_application/pb_crypto/: pb_crypto.c
  group pb_multimedia
    ../../modules/pb_application/pb_multimedia/: pb_multimedia.c
  group pb_ble
    ../../modules/pb_application/pb_ble/: pb_ble_main.c
  group pb_gui
    ../../modules/pb_application/pb_gui/: pb_gui_main.c
  group pb_prot
    ../../modules/pb_application/pb_prot/: pb_prot_assemble.c pb_prot_cmd.c pb_prot_main.c pb_prot_parse.c pb_prot_proc.c
  group pb_order
    ../../modules/pb_application/pb_order/: pb_order_list.c pb_order_main.c pb_order_hotp.c
  group pb_ota
    ../../modules/pb_application/pb_ota/: pb_ota_main.c pb_ota_network.c
  group pb_cfg
    ../../modules/pb_application/pb_cfg/: pb_cfg_default.c pb_cfg_proc.c
  group network_util
    ../../modules/network_util/: dhcp.c dns.c
  group crypto
    ../../modules/crypto/: aes.c hmac_sha256.c md5.c sha256.c
  group drivers
    ../../modules/drivers/gsm/m26/: m26.c
    ../../modules/drivers/screen/oled/: font.c sh1106.c
    ../../modules/drivers/rgbLed/: rgb_led_task.c
    ../../modules/drivers/ir/: ir_remote_control.c ac_control.c
    ../../modules/drivers/audio/kt603/: kt603.c pam8610.c
    ../../modules/drivers/eth/: w5500.c
    ../../modules/drivers/bt/hm11/: hm11.c
  group hal
    ../../hardware/hal/: hal_board.c hal_gpio.c hal_usart.c hal_wdg.c hal_bkp.c hal_rtc.c hal_flash.c hal_rcc.c hal_sw_i2c.c hal_tim.c hal_spi.c
  group middleware
    ../../middleware/: os_datastruct.c os_middleware.c os_trace_log.c os_task_define.c
  group freertos
    ../../thirdparty/FreeRTOS/Source/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_protable_stm32f1xx
    ../../thirdparty/FreeRTOS/Source/portable/stm32f1xx/: port.c
  group stm32f1xx_std_drv_lib
    ../../hardware/board/stm32f1xx/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group stm32f1xx_startup
    ../../hardware/board/stm32f1xx/startup/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group freertos_protable_stm32f4xx
    ../../thirdparty/FreeRTOS/Source/portable/stm32f4xx/: port.c
  group stm32f4xx_std_drv_lib
    ../../hardware/board/stm32f4xx/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group stm32f4xx_startup
    ../../hardware/board/stm32f4xx/startup/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f427x.s
target stm32f1xx_app (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: pb_app +hex
  AfterMake: fromelf.exe --bin -o f103_app/pb_app.bin f103_app/pb_app.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,BOARD_STM32F1XX,PB_APPLICATION
  c include: ..\..\common;..\..\hardware\board\stm32f1xx\startup;..\..\hardware\board\stm32f1xx\STM32F10x_StdPeriph_Driver\inc;..\..\hardware\board\stm32f1xx;..\..\hardware\hal;..\..\thirdparty\FreeRTOS\Source\include;..\..\thirdparty\FreeRTOS\Source\portable\stm32f1xx;..\..\middleware;..\..\modules\pb_application;..\..\modules\pb_application\pb_cfg;..\..\modules\pb_application\pb_prot;..\..\modules\pb_application\pb_crypto;..\..\modules\pb_application\pb_util;..\..\modules\pb_application\pb_gui;..\..\modules\pb_application\pb_multimedia;..\..\modules\pb_application\pb_io;..\..\modules\pb_application\pb_fota;..\..\modules\pb_application\pb_ota;..\..\modules\drivers\gsm\m26;..\..\modules\crypto;..\..\modules\drivers\screen\oled;..\..\modules\drivers\rgbLed;..\..\modules\drivers\ir;..\..\modules\drivers\audio\kt603;..\..\modules\drivers\eth;..\..\modules\network_util;..\..\modules\pb_application\pb_order;..\..\modules\pb_firmware_manage
  memory RVCT4: ROM 0x8004000 size 0x2a000
  memory RVCT9: RAM 0x20000000 size 0x10000
target stm32f4xx_bl (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pb_bl +hex
  AfterMake: fromelf.exe --bin -o f427_bl/pb_bl.bin f427_bl/pb_bl.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,BOARD_STM32F4XX,PB_BOOTLOADER
  c include: ..\..\common;..\..\hardware\board\stm32f4xx\startup;..\..\hardware\board\stm32f4xx\STM32F4xx_StdPeriph_Driver\inc;..\..\hardware\board\stm32f4xx;..\..\hardware\hal;..\..\thirdparty\FreeRTOS\Source\include;..\..\thirdparty\FreeRTOS\Source\portable\stm32f4xx;..\..\middleware;..\..\modules\pb_bootloader;..\..\modules\pb_firmware_manage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target stm32f4xx_app (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: as above
  output: pb_app +hex
  AfterMake: fromelf.exe --bin -o f427_app/pb_app.bin f427_app/pb_app.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,BOARD_STM32F4XX,PB_APPLICATION
  c include: ..\..\common;..\..\hardware\board\stm32f4xx\startup;..\..\hardware\board\stm32f4xx\STM32F4xx_StdPeriph_Driver\inc;..\..\hardware\board\stm32f4xx;..\..\hardware\hal;..\..\thirdparty\FreeRTOS\Source\include;..\..\thirdparty\FreeRTOS\Source\portable\stm32f4xx;..\..\middleware;..\..\modules\pb_application;..\..\modules\pb_application\pb_cfg;..\..\modules\pb_application\pb_prot;..\..\modules\pb_application\pb_crypto;..\..\modules\pb_application\pb_util;..\..\modules\pb_application\pb_gui;..\..\modules\pb_application\pb_multimedia;..\..\modules\pb_application\pb_io;..\..\modules\pb_application\pb_fota;..\..\modules\pb_application\pb_ota;..\..\modules\drivers\gsm\m26;..\..\modules\crypto;..\..\modules\drivers\screen\oled;..\..\modules\drivers\rgbLed;..\..\modules\drivers\ir;..\..\modules\drivers\audio\kt603;..\..\modules\drivers\eth;..\..\modules\network_util;..\..\modules\pb_application\pb_order;..\..\modules\pb_firmware_manage;..\..\modules\pb_application\pb_ble;..\..\modules\drivers\bt\hm11
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.1.1
